<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.5'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>test_device3</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1e6</value></param>
</block>
<block>
<key>variable_uhd_device3</key>
<param><key>id</key><value>device3</value></param>
<param><key>dev_addr</key><value>type=x300</value></param>
<param><key>dev_args</key><value>""</value></param>
</block>
<block>
<key>uhd_rfnoc_streamer</key>
<param><key>id</key><value>rfnoc_ce</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>block_id</key><value>FFT</value></param>
<param><key>stream_args</key><value>spp=64</value></param>
<param><key>sregs</key><value>{}</value></param>
<param><key>named_options</key><value>{}</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>label1</key><value></value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label2</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
</block>
<block>
<key>uhd_rfnoc_streamer_fifo</key>
<param><key>id</key><value>uhd_rfnoc_streamer_fifo_1</value></param>
<param><key>block_index</key><value>1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rx_freq</value></param>
<param><key>value</key><value>1.982e9</value></param>
<param><key>start</key><value>1e9</value></param>
<param><key>stop</key><value>2e9</value></param>
<param><key>step</key><value>1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
</block>
<block>
<key>uhd_rfnoc_streamer_radio</key>
<param><key>id</key><value>uhd_rfnoc_streamer_radio_0</value></param>
<param><key>radio_index</key><value>0</value></param>
<param><key>stream_args</key><value></value></param>
<param><key>tx_freq</key><value>1.982e9</value></param>
<param><key>tx_rate</key><value>1e6</value></param>
<param><key>tx_gain</key><value>20</value></param>
<param><key>rx_ant</key><value>"TX/RX"</value></param>
<param><key>rx_freq</key><value>rx_freq</value></param>
<param><key>rx_rate</key><value>1e6</value></param>
<param><key>rx_gain</key><value>20</value></param>
</block>
<block>
<key>uhd_rfnoc_streamer_fifo</key>
<param><key>id</key><value>uhd_rfnoc_streamer_fifo_0</value></param>
<param><key>block_index</key><value>0</value></param>
</block>
<block>
<key>uhd_rfnoc_streamer</key>
<param><key>id</key><value>rfnoc_fir</value></param>
<param><key>block_id</key><value>FIR</value></param>
<param><key>stream_args</key><value></value></param>
<param><key>sregs</key><value>{}</value></param>
<param><key>named_options</key><value>{}</value></param>
</block>
<connection><source_block_id>rfnoc_ce</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_rfnoc_streamer_radio_0</source_block_id><sink_block_id>rfnoc_fir</sink_block_id><source_key>out_f</source_key><sink_key>in_f</sink_key></connection>
<connection><source_block_id>uhd_rfnoc_streamer_radio_0</source_block_id><sink_block_id>rfnoc_ce</sink_block_id><source_key>out_f</source_key><sink_key>in_f</sink_key></connection>
<connection><source_block_id>uhd_rfnoc_streamer_fifo_1</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_rfnoc_streamer_fifo_0</source_block_id><sink_block_id>uhd_rfnoc_streamer_fifo_1</sink_block_id><source_key>out_f</source_key><sink_key>in_f</sink_key></connection>
<connection><source_block_id>rfnoc_fir</source_block_id><sink_block_id>uhd_rfnoc_streamer_fifo_0</sink_block_id><source_key>out_f</source_key><sink_key>in_f</sink_key></connection>
</flow_graph>
